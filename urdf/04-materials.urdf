Commit message: Turn the legs right round baby right round

File: urdf/04-materials.urdf (robot description, URDF)
Before this commit: robot materials, 3 links, 2 joints
Links:
- link left_leg: geometry visual box size=0.6 .1 .2
- link right_leg: geometry visual box size=0.6 .1 .2
