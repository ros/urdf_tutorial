Commit message: Add missing line

File: urdf/06-flexible.urdf (robot description, URDF)
Before this commit: robot visual, 16 links, 15 joints
Joints:
- joint head_swivel: axis (none) -> 0 0 1
